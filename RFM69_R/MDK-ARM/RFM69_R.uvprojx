# Keil uVision project RFM69_R.uvprojx, settings and files
target RFM69_R (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)   CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RFM69_R +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ..\..\..\..\LIB\STM32_Cryptographic\Inc;                  ..\..\LIB\RFM69_C;                  ..\..\LIB\BASE_IO;                  ../Drivers/STM32F4xx_HAL_Driver/Inc;                  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                  ../Middlewares/Third_Party/FreeRTOS/Source/include;                  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                  ../Drivers/CMSIS/Include;                  ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;                  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;                  ..\..\LIB\CRYPTO_CLASS;                  ../Core/Inc
  asm include: ..\Inc;..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_5.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group RFM69_C
    ../../LIB/RFM69_C/: RF69_ACK.c RFM69_.c RF69_ACK.h RFM69_.h Use_RFM69_.c.txt RFM69registers.h TIMER_C.h TIMER_C.c
    ../Core/Inc/: RFM69_Config.h
  group BASE_IO
    ../../LIB/BASE_IO/: BASE_DEF.c BASE_DEF.h CRC_GEN.c CRC_GEN.h
    ../../LIB/CRYPTO_CLASS/: RND_GEN.h RND_GEN.c
  group Crypto
    ../../../../LIB/STM32_Cryptographic/Inc/: config.h crypto.h
    ../../../../LIB/STM32_Cryptographic/Lib/: STM32CryptographicV3.0.0_CM4_KEIL_otslsm1elfspf.lib
  group Application/User/Core
    ../Core/Inc/: MyAppConfig.h
    ../Core/Src/: main.c gpio.c freertos.c crc.c dma.c i2c.c rtc.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
software components: CMSIS:CORE 5.4.0
